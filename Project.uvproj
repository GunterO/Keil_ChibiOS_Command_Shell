# Keil uVision project Project.uvproj, settings and files
target STM32F429I-DISCO (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=4 oTime=1 uC99=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c include: ..\ChibiOS_Template;.\os\kernel\include;.\os\ports\common\ARMCMx;.\os\ports\common\ARMCMx\CMSIS\include;.\os\ports\RVCT\ARMCMx;.\os\ports\RVCT\ARMCMx\STM32F4xx;.\os\hal\include;.\os\hal\platforms\STM32;.\os\hal\platforms\STM32\GPIOv2;.\os\hal\platforms\STM32\OTGv1;.\os\hal\platforms\STM32F4xx;.\os\various;.\conf;.\test
  asm misc: --cpreproc
  asm include: ..\ChibiOS_Template;.\conf;.\os\ports\RVCT\ARMCMx\STM32F4xx
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x1
  group main
    ./: main.c usbcfg.c usbcfg.h
  group conf
    ./conf/: board.c board.h chconf.h halconf.h mcuconf.h
  group os
    ./os/kernel/src/: chlists.c chschd.c chsem.c chsys.c chthreads.c chvt.c chdynamic.c chheap.c chmemcore.c chcond.c chdebug.c chevents.c chmboxes.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c
    ./os/various/: chprintf.c shell.c memstreams.c chrtclib.c evtimer.c
  group hal
    ./os/hal/src/: hal.c pal.c usb.c serial_usb.c
  group platform
    ./os/hal/platforms/STM32F4xx/: hal_lld.c stm32_dma.c
    ./os/hal/platforms/STM32/GPIOv2/: pal_lld.c
    ./os/hal/platforms/STM32/OTGv1/: usb_lld.c
  group port
    ./os/ports/RVCT/ARMCMx/: chcore.c chcore_v7m.c cstartup.s chcoreasm_v7m.s
    ./os/ports/RVCT/ARMCMx/STM32F4xx/: vectors.s
    ./os/ports/common/ARMCMx/: nvic.c
  group test
    ./test/: test.c testbmk.c testdyn.c testevt.c testheap.c testmbox.c testmsg.c testmtx.c testpools.c testqueues.c testsem.c testthd.c
